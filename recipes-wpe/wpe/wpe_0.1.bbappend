SRCREV ?= "ef7e5722363f1aeca877b344d55ed5c81df21e97"
PACKAGECONFIG_remove = "${PROVISIONING}"
PACKAGECONFIG_remove = "${WL_BUFFER_MANAGEMENT}"
WESTEROS_SRCREV ?= "1edd118cfcb227cc6721c8802afbac7469699d13"
