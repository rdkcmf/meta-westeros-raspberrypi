IMAGE_INSTALL_remove = "packagegroup-ml-middleware"
IMAGE_INSTALL_remove = "netflix"
IMAGE_FEATURES_remove = "ssh-server-openssh"
